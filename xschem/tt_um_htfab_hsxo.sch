v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 380 -590 560 -590 {lab=VGND}
C {devices/ipin.sym} 160 -920 0 0 {name=p1 lab=ena}
C {devices/ipin.sym} 160 -900 0 0 {name=p2 lab=clk}
C {devices/ipin.sym} 160 -880 0 0 {name=p3 lab=rst_n}
C {devices/ipin.sym} 160 -860 0 0 {name=p4 lab=ui_in[7:0]}
C {devices/ipin.sym} 160 -820 0 0 {name=p5 lab=uio_in[7:0]}
C {devices/opin.sym} 240 -920 0 0 {name=p6 lab=uo_out[7:0]}
C {devices/opin.sym} 240 -900 0 0 {name=p7 lab=uio_out[7:0]}
C {devices/opin.sym} 240 -880 0 0 {name=p8 lab=uio_oe[7:0]}
C {devices/iopin.sym} 160 -720 0 1 {name=p9 lab=VAPWR}
C {devices/iopin.sym} 160 -700 0 1 {name=p10 lab=VDPWR}
C {devices/iopin.sym} 160 -680 0 1 {name=p11 lab=VGND}
C {devices/iopin.sym} 160 -780 0 1 {name=p12 lab=ua[7:0]}
C {devices/lab_pin.sym} 890 -840 0 0 {name=p13 sig_type=std_logic lab=VDPWR}
C {ignore.sym} 160 -920 0 0 {name=l1}
C {ignore.sym} 160 -900 0 0 {name=l2}
C {ignore.sym} 160 -880 0 0 {name=l3}
C {ignore.sym} 160 -820 0 0 {name=l4}
C {ignore.sym} 160 -760 0 0 {name=l5}
C {devices/lab_pin.sym} 440 -790 0 0 {name=p17 sig_type=std_logic lab=VDPWR}
C {devices/lab_pin.sym} 970 -800 0 1 {name=p20 sig_type=std_logic lab=uo_out[7:1],ignore}
C {devices/lab_pin.sym} 560 -590 0 1 {name=p24 sig_type=std_logic lab=VGND}
C {devices/lab_pin.sym} 970 -690 0 1 {name=p25 sig_type=std_logic lab=uio_out[7:0]}
C {devices/lab_pin.sym} 560 -790 0 1 {name=p50 sig_type=std_logic lab=VAPWR}
C {devices/lab_pin.sym} 330 -650 0 0 {name=p60 sig_type=std_logic lab=ua[1]}
C {devices/lab_pin.sym} 670 -650 0 1 {name=p61 sig_type=std_logic lab=ua[0]}
C {devices/lab_pin.sym} 330 -750 0 0 {name=p62 sig_type=std_logic lab=ua[2]}
C {devices/lab_pin.sym} 970 -580 0 1 {name=p70 sig_type=std_logic lab=uio_oe[7:0]}
C {devices/lab_pin.sym} 890 -760 0 0 {name=p71 sig_type=std_logic lab=VGND}
C {sky130_ht_ip__hsxo_cpz1.sym} 500 -690 0 0 {name=X1}
C {devices/lab_pin.sym} 330 -710 0 0 {name=p33 sig_type=std_logic lab=ui_in[0]}
C {devices/lab_pin.sym} 330 -690 0 0 {name=p34 sig_type=std_logic lab=ui_in[1]}
C {devices/lab_pin.sym} 670 -670 0 1 {name=p35 sig_type=std_logic lab=uo_out[0]}
C {ignore.sym} 160 -840 0 0 {name=l6}
C {tie_lows.sym} 890 -800 0 0 {name=x2}
C {devices/lab_pin.sym} 890 -730 0 0 {name=p14 sig_type=std_logic lab=VDPWR}
C {devices/lab_pin.sym} 890 -650 0 0 {name=p16 sig_type=std_logic lab=VGND}
C {tie_lows.sym} 890 -690 0 0 {name=x3}
C {devices/lab_pin.sym} 890 -620 0 0 {name=p18 sig_type=std_logic lab=VDPWR}
C {devices/lab_pin.sym} 890 -540 0 0 {name=p19 sig_type=std_logic lab=VGND}
C {tie_lows.sym} 890 -580 0 0 {name=x4}
C {devices/lab_pin.sym} 1120 -780 0 0 {name=p21 sig_type=std_logic lab=ignore}
C {ignore.sym} 1120 -780 0 0 {name=l7}
C {devices/lab_pin.sym} 160 -760 0 0 {name=p22 sig_type=std_logic lab=ua[7:3]}
C {devices/lab_pin.sym} 160 -840 0 0 {name=p15 sig_type=std_logic lab=ui_in[7:2]}
