v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {devices/lab_pin.sym} 90 -200 0 0 {name=p4 sig_type=std_logic lab=DVDD}
C {devices/lab_pin.sym} 170 -200 0 1 {name=p6 sig_type=std_logic lab=AVDD}
C {devices/lab_pin.sym} 280 -170 0 1 {name=p9 sig_type=std_logic lab=uo_out[7:1],DOUT}
C {devices/lab_pin.sym} 130 -60 0 1 {name=p15 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} -20 10 0 0 {name=p1 sig_type=std_logic lab=IBIASPAD,XINPAD,XOUTPAD}
C {devices/lab_pin.sym} 280 10 0 1 {name=p22 sig_type=std_logic lab=IBIAS,XIN,XOUT}
C {devices/lab_pin.sym} -20 50 0 0 {name=p25 sig_type=std_logic lab=GND}
C {devices/iopin.sym} -370 -200 0 0 {name=p32 lab=DVDD}
C {devices/iopin.sym} -370 -140 0 0 {name=p33 lab=GND
}
C {devices/iopin.sym} -370 -170 0 0 {name=p34 lab=AVDD}
C {devices/ipin.sym} -300 -60 0 0 {name=p36 lab=ENA}
C {devices/ipin.sym} -300 -30 0 0 {name=p37 lab=STDBY}
C {devices/ipin.sym} -300 20 0 0 {name=p38 lab=XIN}
C {devices/opin.sym} -370 50 0 0 {name=p39 lab=XOUT}
C {devices/opin.sym} -370 80 0 0 {name=p40 lab=DOUT}
C {devices/ipin.sym} -300 -90 0 0 {name=p41 lab=IBIAS}
C {pad_model.sym} 130 30 0 0 {name=x2[2:0]}
C {tt_um_htfab_hsxo.sym} 130 -130 0 0 {name=x1}
C {devices/lab_pin.sym} 280 -90 0 1 {name=p5 sig_type=std_logic lab=ua[7:3],IBIASPAD,XINPAD,XOUTPAD}
C {ignore.sym} 280 -150 0 0 {name=l1}
C {ignore.sym} 280 -130 0 0 {name=l2}
C {devices/lab_pin.sym} -20 -90 0 0 {name=p8 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} -20 -110 0 0 {name=p11 sig_type=std_logic lab=6*GND,STDBY,ENA}
C {devices/lab_pin.sym} -20 -170 0 0 {name=p3 sig_type=std_logic lab=DVDD}
C {devices/lab_pin.sym} -20 -150 0 0 {name=p7 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} -20 -130 0 0 {name=p10 sig_type=std_logic lab=DVDD}
